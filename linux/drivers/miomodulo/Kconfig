## linux/drivers/miomodulo/Kconfig
```kconfig
#file kernels mio

config miomodulo
	tristate "modulo bello"
	default y
	help
		best modulo of ever letsgoski
```
